# Keil uVision project FT8739_test.uvproj, settings and files
target FT8739_Dram (MCS-251)
  device: Flip80251 Hurricane Dolphin
  cpu: IRAM(0 - 0x41F) CLOCK(16000000) IROM(0xFF0000-0xFF3FFF)
  output: mcu +hex
  AfterMake: ..\output\post_build.BAT
  group start
    ../../src/: main.c START251.A51
