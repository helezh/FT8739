# Keil uVision project FT8836-romboot.uvproj, settings and files
target Target 1 (MCS-251)
  device: Flip80251 Hurricane Dolphin
  cpu: IRAM(0 - 0x41F) CLOCK(16000000) IROM(0xFF0000-0xFF3FFF)
  output: mcu +hex
  AfterMake: ..\output\post_build.BAT
  group source
    ../source/: START251.A51 Main.c
  group debug
    ../source/Debug/: uart.c
  group Drv
    ../source/Drv/: Drv_mcu.c
