# Keil uVision project FT8836_test.uvproj, settings and files
target FT8836_Dram (MCS-251)
  device: Flip80251 Hurricane Dolphin
  cpu: IRAM(0 - 0x41F) CLOCK(16000000) IROM(0xFF0000-0xFF3FFF)
  output: mcu +hex
  AfterMake: ..\output\post_build.BAT
  group start
    ../../src/: main.c START251.A51 test_pram1.c test_pram2.c
