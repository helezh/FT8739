# Keil uVision project FT8836_all.uvproj, settings and files
target FT8836_all (MCS-251)
  device: Flip80251 Hurricane Dolphin
  cpu: IRAM(0 - 0x41F) CLOCK(16000000) IROM(0xFF0000-0xFF3FFF)
  output: mcu +hex
  AfterMake: ..\output\post_build.bat
  group start
    ../../src/source/driver/: START251.A51
  group flow
    ../../src/source/flow/: main.c FlowFactory.c FlowUpgrade.c FlowWork.c CfgAutoTune.c
  group app
    ../../src/source/app/: AppSysCtrl.c AppHostComm.c AppVersion_Lib.c AppParameter.c
  group driver
    ../../src/source/driver/: DrvSysCtrl.c DrvHostComm.c DrvAfePara.c DrvAsmCtrl.c
  group debug
    ../../src/source/Debug/: uart.c TestRwSFR.c
  group lib_drv
    ../../src/source/lib_drv/: LibDrv.c
