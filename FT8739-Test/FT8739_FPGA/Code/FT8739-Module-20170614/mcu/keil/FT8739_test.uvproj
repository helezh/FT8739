# Keil uVision project FT8739_test.uvproj, settings and files
target FT8739_test (MCS-251)
  device: Flip80251 Hurricane Dolphin
  cpu: IRAM(0 - 0x41F) CLOCK(16000000) IROM(0xFF0000-0xFF3FFF)
  output: mcu +hex
  AfterMake: ..\output\post_build.BAT
  group start
    ../../src/source/: main.c
    ../../src/source/driver/: START251.A51
  group task
    ../../src/source/task/: Test_Afe.c Test_Aram.c Test_CAL.c Test_counter.c Test_Dram.c Test_GPIO.c Test_gpio_wakeup.c Test_i2c.c Test_i2c_wakeup.c Test_int_nest.c Test_LED.c Test_Prom.c Test_Reg.c Test_romboot.c Test_RTC.c Test_SFR.c Test_spi.c Test_timer.c Test_wdt.c Test_Xbus.c Test_RomEcc.c Test_Uart.c Test_SFT_RST.c Test_spi0.c Test_spi0_dma.c Test_spi0_wakeup.c Test_DebugOut.c Test_Reset.c
  group driver
    ../../src/source/driver/: Drv_Cal.c Drv_mcu.c Drv_XSI.c Drv_XBUS.c crckrmit.c Drv_CRC.c
  group debug
    ../../src/source/Debug/: uart.c
